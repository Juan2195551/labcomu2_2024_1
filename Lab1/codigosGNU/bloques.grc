options:
  parameters:
    author: bradlee_castro
    generate_options: qt_gui
    id: bloques
    output_language: python
    title: practica2
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: DES_ESTANDAR
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DES_ESTANDAR"'
    type: float
  states: {}
- name: M_cuadratica
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"M_cuadratica"'
    type: float
  states: {}
- name: POT_PROMEDIO
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"POT_PROMEDIO"'
    type: float
  states: {}
- name: RMS
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"RMS"'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '15'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: float
    vector: (1, 2, -1)
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  

          def __init__(self):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='e_ACUM',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
             
             
          def work(self, input_items, output_items):
              """example: multiply with constant"""
              x = input_items[0]
              y0 = output_items[0]
              y0[:] = np.cumsum(x)
              return len(y)
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
              
                    
         
      class blk (gr.sync_block):
      	def __init__(self): # only default arguments here
      	   gr.sync_block.__init__(
      		self,
      		name ="e_Diff", # will show up in GRC
      		in_sig =[ np. float32 ],
      		out_sig =[ np. float32 ]
      		
      	   
      	   )
      	   self.acum_anterior = 0
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Senial acumulada diferencial
      		
      		N = len (x)
      		diff = np.cumsum (x) - self.acum_anterior
      		self.acum_anterior = diff [N-1]
      		y0 [:] = diff
      		return len (y)
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr



      class blk (gr.sync_block ):

      	def __init__ (self) : # only default arguments here
      		gr.sync_block.__init__(
      			self,
      			name ="Promedios_de_tiempos", # will show up in GRC
      			in_sig =[ np. float32 ],
      			out_sig =[ np. float32 ,np. float32 ,np. float32 ,np. float32 ,np. float32 ]
      		)
      		self . acum_anterior = 0
      		self . Ntotales = 0
      		self . acum_anterior1 = 0
      		self . acum_anterior2 = 0
      		
      	def work (self , input_items , output_items ):
      		x = input_items [0] # Senial de entrada .
      		y0 = output_items [0] # Promedio de la senial
      		y1 = output_items [1] # Media de la senial
      		y2 = output_items [2] # RMS de la senial
      		y3 = output_items [3] # Potencia promedio de la senial
      		y4 = output_items [4] # Desviacion estandar de la senial
      		# Calculo del promedio
      		N = len (x)
      		self.Ntotales = self.Ntotales + N
      		acumulado = self.acum_anterior + np.cumsum (x)
      		self.acum_anterior = acumulado [N -1]
      		y0 [:]= acumulado / self.Ntotales
      		# Calculo de la media cuadratica
      		x2=np.multiply (x,x)
      		acumulado1 = self.acum_anterior1 + np.cumsum (x2)
      		self.acum_anterior1 = acumulado [N -1]
      		y1 [:] = acumulado1 / self.Ntotales
      		# Calculo de la RMS
      		y2 [:] = np.sqrt (y1)
      		# Calculo de la potencia promedio
      		y3 [:] = np.multiply (y2 ,y2)
      		# Calculo de la desviacion estandar
      		x3 = np.multiply(x-y0 ,x-y0)
      		acumulado2 = self.acum_anterior2 + np.cumsum (x3)
      		self.acum_anterior2 = acumulado2 [N -1]
      		y4 [:] = np.sqrt ( acumulado2 / self . Ntotales )
      		
      		return len (x)
  states: {}
- name: media
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"media"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', epy_block_0, '0']
- [blocks_add_xx_0, '0', epy_block_1, '0']
- [epy_block_0, '0', epy_block_2, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '1']
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1, '0', qtgui_time_sink_x_0, '1']
- [epy_block_2, '0', media, '0']
- [epy_block_2, '1', M_cuadratica, '0']
- [epy_block_2, '2', RMS, '0']
- [epy_block_2, '3', POT_PROMEDIO, '0']
- [epy_block_2, '4', DES_ESTANDAR, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
